# Repository petrsykora/pylontech_Lan_Interface

## EAGLE design PCB_design/pylontec_mqttinterface1b.brd

Parts:
485TERM: JP1E; JP1
C1, C35: 100nF; C0805
C2: 47n; C0805
C3, C4, C5: 330n; C0805
C6, C7, C8, C9, C10: 1uF; C1210
CAN: W237-102
CTERM: JP1E; JP1
IC1: MAX3232CSE; SO16
IC2: SN65HVD230; SO8
IC3: MAX485; SO08
LED1: LED_LEDCHIPLED_0805; LED_CHIPLED_0805
NRF24L01+: MA04-2
PROG: JP1E; JP1
Q1, Q2: BSS123; SOT23
R1, R3, R4, R5, R10, R11, R12, R13: 10k; R0805
R2: 180R; R0805
R6, R7: 120R; R0805
R8, R9: 1k; R0805
RS485: MA04-1
SJ1, SJ2, SJ3, SJ4: SJ
TO-FTDI: MA04-1
U$2: WT32-ETH01
X1: RJ45-8L-B; RJ45-NO-SHIELD
X2: SMARTPRJ_PN61729

Connections:
+3V3: C7.1, C10.1, C35.2, IC2.3 (+5V), IC3.8 (VCC), NRF24L01+.7, Q1.1 (G), Q2.1 (G), R3.1, R5.1, R10.1, R11.1, R12.1, R13.1, SJ4.1, U$2.3V3@1 (3V3)
+5V: C1.2, C6.1, C8.1, C9.1, IC1.16 (VCC), R1.1, R4.1, RS485.1, TO-FTDI.4, U$2.5V, X2.1
A: 485TERM.2, IC3.6 (A), R9.1, RS485.3
B: IC3.7 (B), R7.1, R8.2, RS485.2
CANH: CAN.2, IC2.7 (CANH), R6.1
CANL: CAN.1, CTERM.2, IC2.6 (CANL)
CANRXD: IC2.4 (RXD), SJ3.1
CANTXD: IC2.1 (TXD), SJ2.1
CE: IC3.3 (DE), NRF24L01+.6, R11.2, U$2.IO14
CSN: IC3.2 (RE/), NRF24L01+.5, R12.2, U$2.IO15
GND: C1.1, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C35.1, IC1.15 (GND), IC2.2 (GND), IC2.8 (STB), IC3.5 (GND), NRF24L01+.8, PROG.2, R2.2, RS485.4, SJ1.2, TO-FTDI.1, U$2.GND, U$2.GND@2 (GND), U$2.GND@3 (GND), U$2.GND@4 (GND), X1.8, X2.4
IRQ: NRF24L01+.1, U$2.485_EN
MISO: NRF24L01+.2, SJ2.2, U$2.IO4
MOSI: NRF24L01+.3, SJ3.2, U$2.IO2
unnamed: IC1.8 (R2IN), X1.3
unnamed: C2.1, IC1.1 (C1+)
unnamed: PROG.1, U$2.IO0
unnamed: C2.2, IC1.3 (C1-)
unnamed: C3.1, IC1.4 (C2+)
unnamed: C3.2, IC1.5 (C2-)
unnamed: C4.1, IC1.6 (V-)
unnamed: C5.1, IC1.2 (V+)
unnamed: IC1.7 (T2OUT), X1.6
unnamed: LED1.A, U$2.IO12
unnamed: LED1.C, R2.1
unnamed: 485TERM.1, R7.2
unnamed: CTERM.1, R6.2
unnamed: R9.2, SJ1.1
unnamed: R8.1, SJ4.2
RX0: TO-FTDI.3, U$2.RX0
RX_H: IC1.9 (R2OUT), Q2.3 (D), R4.2
RX_L: IC3.1 (RO), Q2.2 (S), R5.2, R10.2, U$2.RXD
SCK: NRF24L01+.4, U$2.CFG
TX0: TO-FTDI.2, U$2.TX0
TX_H: IC1.10 (T2IN), Q1.3 (D), R1.2
TX_L: IC3.4 (DI), Q1.2 (S), R3.2, R13.2, U$2.TXD

Notes on the sheet:
ingmarsretro
Universal LAN-Interface LAN / RS232 / CAN / RS485 / NR42L01
07.12.2023 first draft 01.02.2025 added RS485 + CAN Tranceiver removed ESP8266 added WT32-ETH01 interface 10.02.2025 drill diamater of WT32-ETH01 module fixed
if jumper PROG is set, programming mode of WT32 is active
DO NOT assemble both chips MAX485 or MAX2323 EITHER MAX485 OR MAX2323 ... see schematic
also use EITHER CAN OR NRF24L01 but not both at the same time

Board: 2 copper layers, 63.8 x 62.0 mm, 44 parts (12 on the bottom side), 36 nets.

File PCB_design/BOM_pylontec_mqttinterface1b.txt (part):

Stückliste exportiert aus M:/Projekte/projects_misc/PV/LAN_universalinterface/PCB_design/pylontec_mqttinterface1b.sch am 03.12.2025 09:30

Part      Value      Device              Package          Description                                      AVAILABILITY CHECK_PRICES                                                             DESCRIPTION                                                                                                                                 MF               MP         MPN        OC_FARNELL OC_NEWARK PACKAGE POPULARITY PRICE SNAPEDA_LINK                                                              SPICEPREFIX
485TERM              JP1E                JP1              JUMPER                                                                                                                                                                                                                                                                                                                                                 61                                                                                                    
C1        100nF      C-EUC0805           C0805            CAPACITOR, European symbol                                                                                                                                                                                                                                                                                                                                                                                                                                   
C2        47n        C-EUC0805           C0805            CAPACITOR, European symbol                                                                                                                                                                                                                                                                                                                                                                                                                                   
C3        330n       C-EUC0805           C0805            CAPACITOR, European symbol                                                                                                                                                                                                                                                                                                                                                                                                                                   
C4        330n       C-EUC0805           C0805            CAPACITOR, European symbol                                                                                                                                                                                                                                                                                                                                                                                                                                   
C5        330n       C-EUC0805           C0805            CAPACITOR, European symbol                                                                                                                                                                                                                                                                                                                                                                                                                                   
C6        1uF        C-EUC1210           C1210            CAPACITOR, European symbol                                                                                                                                                                                                                                                                                                                             0                                                                                          C          
C7        1uF        C-EUC1210           C1210            CAPACITOR, European symbol                                                                                                                                                                                                                                                                                                                             0                                                                                          C          
C8        1uF        C-EUC1210           C1210            CAPACITOR, European symbol                                                                                                                                                                                                                                                                                                                             0                                                                                          C          
C9        1uF        C-EUC1210           C1210            CAPACITOR, European symbol                                                                                                                                                                                                                                                                                                                             0                                                                                          C          
C10       1uF        C-EUC1210           C1210            CAPACITOR, European symbol                                                                                                                                                                                                                                                                                                                             0                                                                                          C          
C35       100nF      C-EUC0805           C0805            CAPACITOR, European symbol                                                                                                                                                                                                                                                                                                                                                                                                                                   
CAN                  W237-102            W237-102         WAGO SCREW CLAMP                                                                                                                                                                                                                                                                                               237-102    unknown    70K9898           32                                                                                                    
CTERM                JP1E                JP1              JUMPER                                                                                                                                                                                                                                                                                                                                                 61                                                                                                    
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
## Commit log

2025-12-03 Add files via upload
    the values for capacitors C8,C9 added in schematic . (If it is neccesary to assemble them, depends on the output quality of you 5V USB Supply) in case they are spare
    productionfile for pcb vendors updated
2026-02-17 Add initial configuration for Pylontech monitor
    Configuration for ESPHome
2026-02-17 Create Pylontech HA panel configuration
    Added a new YAML configuration for the Pylontech HA panel with various cards displaying battery metrics.
